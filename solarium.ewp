# IAR project solarium.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC2368 NXP LPC2368
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa039
  ICCARM.CCIncludePath2: OS\app; OS\bsp; OS\uc\cpu; OS\uc\lib; OS\uc\os_ii\port; OS\uc\os_ii\source; DRIVERS\lcd; DRIVERS\keyboard; DRIVERS\fram; DRIVERS\ccnet; DRIVERS\fiscal; DRIVERS\modem; PROJECT; PROJECT\app; PROJECT\service; PROJECT\menu; PROJECT\data; PROJECT\tools
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: solarium_3_39.hex
  ILINK.IlinkOutputFile: solarium.out
  ILINK.IlinkIcfFile: OS\bsp\LPC2368_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group DRIVERS/ccnet
    DRIVERS/ccnet/: CCRSProtocol.c CCRSProtocol.h uart1.c uart1.h VMCConst.h
  group DRIVERS/fiscal
    DRIVERS/fiscal/: fiscal.c fiscal.h uart0.c uart0.h
  group DRIVERS/fram
    DRIVERS/fram/: fram.c fram.h spi.c spi.h
  group DRIVERS/keyboard
    DRIVERS/keyboard/: keyboard.c keyboard.h
  group DRIVERS/lcd
    DRIVERS/lcd/: lcd.c lcd.h symtab.h
  group DRIVERS/modem
    DRIVERS/modem/: modem.c modem.h uart2.c uart2.h
  group OS/app
    OS/app/: app.c app_cfg.h includes.h os_cfg.h
  group OS/bsp
    OS/bsp/: bsp.c bsp.h cstartup.s iolpc2368.h LPC2368_Flash.icf LPC2368_Flash.mac
  group OS/uc/cpu
    OS/uc/cpu/: cpu.h cpu_a.s cpu_def.h
  group OS/uc/lib
    OS/uc/lib/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group OS/uc/os_ii/port
    OS/uc/os_ii/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_dcc.c
  group OS/uc/os_ii/source
    OS/uc/os_ii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group PROJECT
    PROJECT/: version.h
  group PROJECT/app
    PROJECT/app/: app_serv.c app_serv.h control.c control.h journal.c journal.h modem_task.c modem_task.h
  group PROJECT/data
    PROJECT/data/: data.c data.h datadesc.c datadesc.h fram_map.h
  group PROJECT/menu
    PROJECT/menu/: menu.c menu.h menudesc.c menudesc.h
  group PROJECT/service
    PROJECT/service/: coin.c coin.h fr.c fr.h mode.c mode.h time.c time.h validator.c validator.h
  group PROJECT/tools
    PROJECT/tools/: crc16.c crc16.h
